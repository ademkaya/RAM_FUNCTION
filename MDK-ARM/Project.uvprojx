# Keil uVision project Project.uvprojx, settings and files
target STM32F3-Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F3-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c misc: --C99
  c include: ..\Inc;..\..\F3_Drivers\CMSIS\Include;..\..\F3_Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\F3_Drivers\STM32F3xx_HAL_Driver\Inc;..\..\F3_Drivers\AdM_CommonFuncs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT5: ROM 0x8030000 size 0x500
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: STM32F3-Discovery\STM32F3-Discovery.sct
  link misc: --diag_suppress=L6329
  group Drivers/STM32F3xx_HAL_Driver
    ../../F3_Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_hal_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Example/User
    ../Src/: main.c stm32f3xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32f303xc.s
software components: CMSIS:CORE 5.3.0
